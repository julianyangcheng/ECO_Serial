# Keil uVision project BH-F103.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BH-F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\KEY;..\User\LED;..\User\CONTROL;..\User\nvic;..\User\adc;..\User\dma;..\User\dac;..\User\usart;..\User\TIM;..\User\Port;..\User\ModBus\ascii;..\User\ModBus\functions;..\User\ModBus\include;..\User\ModBus\rtu;..\User\ModBus\tcp;..\User\myrtu;..\User\pbdata;..\User
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/LED/: led.c
    ../User/CONTROL/: control.c
    ../User/nvic/: nvic.c
    ../User/adc/: adc.c
    ../User/dma/: dma.c
    ../User/dac/: dac.c
    ../User/usart/: usart.c
    ../User/TIM/: time.c
    ../User/myrtu/: myrtu.c
  group DOC
    ../Doc/: readme.txt
  group Modbus
    ../User/ModBus/: mb.c
    ../User/ModBus/tcp/: mbtcp.c
    ../User/ModBus/rtu/: mbcrc.c mbrtu.c
    ../User/ModBus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../User/ModBus/ascii/: mbascii.c
  group port
    ../User/Port/: portevent.c portserial.c porttimer.c
